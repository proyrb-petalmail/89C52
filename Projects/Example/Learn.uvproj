# Keil uVision project Learn.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Learn +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./Button/: Button.c
    ./Keyboard/: Keyboard.c
    ./LEDQueue/: LEDQueue.c
    ./Timer/: Timer.c
    ./Buzzer/: Buzzer.c
    ./Digital/: Digital.c
    ./LCD1602/: LCD1602.c
    ./LEDMatrix/: LEDMatrix.c
    ./Motor/: Motor.c
    ./Delay/: Delay.c
